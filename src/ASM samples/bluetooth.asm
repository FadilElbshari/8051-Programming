ORG 0h;


INIT:
	MOV P1, #0FFh; Port 1 init
	MOV SCON, #50h;
	MOV TMOD, #20h;
	MOV PCON, #80h;
	MOV TH1, #0F3h;
	SETB TR1;
	MOV A, #'F';


SENDCHAR:
	SETB P1.0       ; Turn on LED
	CLR TI
	MOV SBUF, A

TXLOOP:
	JNB TI, TXLOOP
	CLR P1.0        ; Turn off LED
	CALL DELAY
	CALL DELAY;
	JMP SENDCHAR

DELAY:
	MOV R0, #0FFh;
DELAYSUB:
	MOV R1, #0FFh;
DELAYSUB2:
	DJNZ R1, DELAYSUB2;
	DJNZ R0, DELAYSUB;
	RET

END